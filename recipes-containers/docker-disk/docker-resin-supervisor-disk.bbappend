#SUPERVISOR_REPOSITORY_imx7d-pico = "resin/armv7hf-supervisor"
